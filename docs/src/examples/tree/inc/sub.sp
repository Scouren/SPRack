.subckt rdiv a b
R1 a b 1k
.ends rdiv
